# Keil uVision project Project.uvprojx, settings and files
target Project (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/STM32F1xx_HAL_Driver/Inc;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Drivers/MCU-F103;../Service;../App/FreeRTOS/Tasks;../Config;../Net/CJSON;../Net/Device;../Net/MQTT;../Net/onenet
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c dma.c i2c.c iwdg.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group Drivers/Bsp
    ../Drivers/MCU-F103/: driver_timer.c driver_timer.h driver_oled.c driver_oled.h driver_oled_font.h driver_adc.c driver_adc.h typedefs.h driver_buzzer.c driver_buzzer.h
    ../App/FreeRTOS/Tasks/: driver_led.c driver_led.h
  group Service
    ../Service/: sensor_service.c sensor_service.h safety_service.c safety_service.h watchdog_service.c watchdog_service.h
  group Application/Task
    ../App/FreeRTOS/Tasks/: sensor_task.c sensor_task.h display_task.c display_task.h process_task.c process_task.h safety_task.c safety_task.h watchdog_task.c watchdog_task.h comm_task.c comm_task.h
  group Application/Net/Device
    ../Net/Device/: esp8266.c esp8266.h
  group Application/Net/MQTT
    ../Net/MQTT/: Common.h MqttKit.c MqttKit.h
  group Application/Net/CJSON
    ../Net/CJSON/: cJSON.c cJSON.h
  group Application/Net/onenet
    ../Net/onenet/: base64.c base64.h hmac_sha1.c hmac_sha1.h onenet.c onenet.h
  group Config
    ../Config/: system_config.h
software components: CMSIS:CORE 4.3.0
